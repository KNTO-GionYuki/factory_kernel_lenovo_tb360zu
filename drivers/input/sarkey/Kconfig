## drivers/input/sarkey/Kconfig
```kconfig
config SAR_KEY_SUPPORT
        tristate "sar key"
        help
          Say Y here if you have sar key.
          If unsure, say N.
```
